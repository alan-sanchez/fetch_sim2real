Commit message: updated files.

File: robots/fetch.urdf (robot description, URDF)
Before this commit: robot fetch, 27 links, 26 joints
Joints:
- joint ee_joint: origin xyz=0 0 0 rpy=1.57079632679 1.57079632679 0 -> xyz=0 0 0 rpy=0 1.57079632679 0
